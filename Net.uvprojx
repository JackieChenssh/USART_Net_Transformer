# Keil uVision project Net.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Net +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ./Library/inc;./Library/src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./Library/src/: Retarget.c
    ./: Net.c
  group Lib
    ./Library/src/: stm32f10x_rcc.c stm32f10x_nvic.c stm32f10x_tim.c stm32f10x_it.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_lcd.c stm32f10x_dma.c
  group StartUp
    ./Library/src/: SystemInit.c
    ./Library/: stm32f10x_vector.s cortexm3_macro.s
  group Net_Lib
    ./Library/src/: Net_Config.c ENC28J60.C
    ./Library/: TCP_CM3.lib
software components: CMSIS:CORE 5.4.0
